# Keil uVision project uart.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\stoplight\inc;C:\Keil_v5\ARM\CMSIS\Include;C:\Keil_v5\ARM\INC
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: main.c bsp.h bsp.c
    ../stoplight/inc/: TM4C123GH6PM.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
